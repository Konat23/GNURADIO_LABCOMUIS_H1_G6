options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Practica1_labComu2_G10_R
    output_language: python
    title: Lab_1_Receptor
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia RX
    start: '0'
    step: '500e-3'
    stop: '315e-1'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: FRecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2200e6
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 125E5
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
